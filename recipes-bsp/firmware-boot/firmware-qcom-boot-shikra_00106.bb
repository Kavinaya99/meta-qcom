require firmware-qcom-boot-shikra.inc

